<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fm_subcarrier_raw_tx</value></param>
<param><key>author</key><value>Zouppen</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>FM subcarrier tx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate_in</value></param>
<param><key>value</key><value>24000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate_out</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>file_path</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>Audio device name</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>subcarrier</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>file_path</value></param>
<param><key>label</key><value>File to read</value></param>
<param><key>short_id</key><value>F</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/dev/stdin</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>fm_audio</value></param>
<param><key>device_name</key><value>device</value></param>
<param><key>samp_rate</key><value>audio_rate_out</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>-subcarrier</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_rate_out</value></param>
<param><key>taps</key><value>firdes.complex_band_pass(1, audio_rate_out, subcarrier+500, subcarrier+3000, 200)</value></param>
<param><key>type</key><value>fcc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>audio_rate_out/audio_rate_in</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subcarrier</value></param>
<param><key>label</key><value>Subcarrier frequency (Hz)</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>66500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value>Subcarrier volume</value></param>
<param><key>short_id</key><value>v</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.125</value></param>
</block>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>fm_audio</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
